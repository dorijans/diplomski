# Keil uVision project diplomski.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F303CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: diplomski
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F303xC, USE_STDPERIPH_DRIVER
  c include: .\;.\Lib;.\header;.\src;.\Lib\Include;.\Lib\STM32F30x_StdPeriph_Driver\inc;.\Lib\STM32F30x_StdPeriph_Driver\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Src
    ./src/: main.c
  group BSP
    ./Lib/: startup_stm32f303xc.s stm32f30x_conf.h system_stm32f30x.c system_stm32f30x.h
  group STM_lib
    ./Lib/STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_gpio.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_syscfg.c
software components: CMSIS:CORE 5.0.0
